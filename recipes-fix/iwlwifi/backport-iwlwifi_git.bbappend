# Remove warning during do package process!
inherit module features_check
